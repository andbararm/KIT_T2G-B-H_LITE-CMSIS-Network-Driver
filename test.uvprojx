# Keil uVision project test.uvprojx, settings and files
target CM0p (6240000::V6.24::ARMCLANG)
  device: CYT4BF8CDS:Cortex-M0p Infineon
  pack: Infineon.T2G-B-H_DFP.1.2.0
  cpu: IRAM(0x28000000,0x100000) IROM(0x10000000,0x830000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_NAME_CM0P
  c include: .\RTE\Device_Configurator\GeneratedSource\
  memory RVCT4: ROM 0x10000000 size 0x830000
  memory RVCT9: RAM 0x28000000 size 0x100000
  scatter file: .\RTE\Device\CYT4BF8CDS_Cortex-M0p\xmc7200d_x8384_cm0plus.sct
  group Source Group 1
    ./: test.c EMAC_T2G.c PHY_DP83825I.c retarget_stdio.c
  group Generated_Source
    ./RTE/Device_Configurator/GeneratedSource/: cycfg.c cycfg_clocks.c cycfg_peripherals.c cycfg_pins.c cycfg_system.c
software components: CMSIS Driver:Ethernet MAC:Custom 1.0.0, CMSIS Driver:Ethernet PHY:Custom 1.0.0, CMSIS:CORE 5.7.0-fusa, CMSIS:RTOS2:Keil RTX5 5.7.0-fusa, Board Support:Board Setup 1.0.0, Device Configurator:Device Configurator 1.0.0, Device:Peripheral Driver Library:PDL 3.10.0, Device:Startup 1.0.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 8.1.0, Network:Interface:ETH 8.1.0, Network:Socket:TCP 8.1.0, Network:Socket:UDP 8.1.0
